# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00100000)
  output: TOUCH
  group USER
    ../USER/: main.c
    ../中文目录/: 中文文件.c
